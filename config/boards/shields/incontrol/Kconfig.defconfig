## config/west.yml
```yaml
manifest:
  projects:
    - name: zmk
      remote: https://github.com/zmkfirmware/zmk
      revision: main
      import: app/west.yml
  self:
    path: config
```
